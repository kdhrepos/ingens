## linux-4.3-ingens/Kconfig.osa
```kconfig
menu "OSA"

config OSA
	tristate "Enable Ingens support."
	default y

config OSA_DEBUG
	tristate "Enable Ingens debugging." 
	default y

endmenu
```
